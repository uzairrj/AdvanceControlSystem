Commit message: inertiaTensorFormulation

File: RPR_xzx.urdf (robot description, URDF)
Before this commit: robot RPR, 5 links, 4 joints
Links:
- link Link2: mass 0 -> 0.2
- link Link3: mass 0 -> 0.3
- link Link4: mass 0 -> 0.4
- link base_link: mass 0 -> 0.1
